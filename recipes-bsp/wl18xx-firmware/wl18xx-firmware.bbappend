SRCREV = "d153edae2a75393937da43159b7e6251c2cd01b6"
BRANCH = "master"
PV = "R8.7"
PR = "r0"
