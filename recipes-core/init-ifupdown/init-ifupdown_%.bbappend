# Copyright (C) 2018 Afero, Inc. All rights reserved
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PACKAGE_ARCH = "${MACHINE_ARCH}"

PR_append = ".tisdk2"

